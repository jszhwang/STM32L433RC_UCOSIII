# IAR project STM32L433RCT6_UCOS3.ewp, settings and files
configuration STM32L433RCT6_UCOS3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L433xx
  ICCARM.CCIncludePath2: ../Inc; ../BSP; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../ThirdParty/Micrium/uCOSIII/uC-CPU; ../ThirdParty/Micrium/uCOSIII/uC-CPU/ARM-Cortex-M4/IAR; ../ThirdParty/Micrium/uCOSIII/uC-LIB; ../ThirdParty/Micrium/uCOSIII/uCOS-III; ../ThirdParty/Micrium/uCOSIII/uCOS-III/Source; ../ThirdParty/Micrium/uCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L433RCT6_UCOS3.hex
  ILINK.IlinkOutputFile: STM32L433RCT6_UCOS3.out
  ILINK.IlinkIcfFile: stm32l433xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l433xx.s stm32l433xx_flash.icf
  group Application/User
    ../Src/: app.c os_app_hooks.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group BSP
    ../BSP/: bsp.c bsp_hal.c cpu_bsp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group ThirdParty/uCOSIII/uC-CPU
    ../ThirdParty/Micrium/uCOSIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../ThirdParty/Micrium/uCOSIII/uC-CPU/: cpu_core.c
  group ThirdParty/uCOSIII/uC-LIB
    ../ThirdParty/Micrium/uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group ThirdParty/uCOSIII/uCOS-III
    ../ThirdParty/Micrium/uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../ThirdParty/Micrium/uCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
