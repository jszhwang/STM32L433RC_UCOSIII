<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L433RCT6_UCOS3.ewp</path>
  </project>
  <batchBuild />
</workspace>
